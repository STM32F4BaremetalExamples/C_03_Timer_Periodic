# Keil uVision project C_03_Timer_Periodic_STM32F4.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: C_03_Timer_Periodic_STM32F4
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./source/: main.c
  group ::Device
    RTE/Device/STM32F411RETx/: startup_stm32f411xe.s system_stm32f4xx.c
software components: CMSIS:CORE 3.40.0, Device:Startup 2.1.0
